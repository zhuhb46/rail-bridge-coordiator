# Keil uVision project LTE.uvprojx, settings and files
target TCP_Client (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Air720_Air724 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\User;..\..\Libraries\FWlib\inc;..\..\Libraries\CMSIS;..\..\Applications\systick;..\..\Applications\lte;..\..\Applications\gpio;..\..\Applications\tim;..\..\Applications\uart;..\..\Applications\lora;..\..\Applications\ADC;..\..\Applications\ChipID;..\..\Applications\IWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group MDK-ARM
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group App
    ../../Applications/lte/: fat_core.c lte_demo.c
    ../../Applications/uart/: uart.c
    ../../Applications/tim/: tim.c
    ../../Applications/gpio/: gpio.c
    ../../Applications/lora/: LoRa.c
    ../../Applications/ADC/: adc.c
    ../../Applications/ChipID/: chipid.c
    ../../Applications/IWDG/: iwdg.c
  group User
    ../../User/: main.c stm32f10x_it.c
